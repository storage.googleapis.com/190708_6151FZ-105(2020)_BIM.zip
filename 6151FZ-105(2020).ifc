Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-09T14:28:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 09 14:28:04 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{A7FB6AE1-F882-4799-B45A-6CE927AF6037}\ifc * Database version: 5507 * Database creation date: Mon Aug 09 14:28:04 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 09 14:28:04 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 09 14:28:04 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6151FZ-105(2020) Washbasin faucet, 6 V, Bluetooth, 6151FZ-105(2021):6151FZ-105(2020) Washbasin faucet, 6 V, Bluetooth:358352
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 155.223 mm; NominalHeight: 127.6 mm; NominalWidth: 66.2929 mm; Projection: 110 mm
Type - Electrical Engineering - Battery: Lithium 2CR5 6 V; Bluetooth: 4.x; Electronic Parts: Autofocus sensor;Solenoid valve;Low battery indication; Operating Voltage: 6 V
Type - General - Author: BIMstone; BIMObjectName: 6151FZ-105(2021); ConvergoRefNr: 0087-2006-0055-FI; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 22/07/2021
Type - Green Building Properties - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150097812; EMC Directive: 2014/53/EU; EN Standard: EN 15091; LVI Number: 6110336; Noise Class: I (ISO 3822); VVS Number: 704271244
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/6151FZ-105; Catalog Drawing URL: http://static.oras.com/catdrw/6151FZ-105; Class: Touchless;Battery-operated;Bluetooth®; Dimension Drawing URL: http://static.oras.com/dimdrw/6151FZ-105; FDV Document URL: http://www.oras.com/datasheet/6151FZ-105/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6151FZ-105; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA; Model: 6151FZ-105(2020) Washbasin faucet, 6 V, Bluetooth; Name_en: 6151FZ-105(2020) Washbasin faucet, 6 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 290 x 210 x 90; Package Weight: 1.736 kg; Product Code: 6151FZ-105(2020); Product Datasheet: http://www.oras.com/datasheet/6151FZ-105/en; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6151FZ-105; Product URL: http://static.oras.com/6151FZ-105; Technical DataSheet URL: http://www.oras.com/datasheet/6151FZ-105/en; Type Name: 6151FZ-105(2020) Washbasin faucet, 6 V, Bluetooth
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Adjustable settings (via bluetooth); Aerator: CACHÉ® integrated aerator;;Pressure controlled aerator; Afterflow Period: 3120; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: FlexibleInletPipes; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00247203 m3/s; Installation and Maintenance: http://static.oras.com/manual/6151FZ-105; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 211800; Mechanical Parts: Mixing valve;Non-return valve(s);Litter filter(s); Mounting Holes: 1MountingHole; Protection Class: IP 55; Spare Parts: http://static.oras.com/sp/6151FZ-105; Spout Type: Fixed spout;; Temperature: Temperature limiter (retrofittable); Temperature Adjustments: Temperature limiter (retrofittable)
Type - Other - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Green Building; CodePerformance: n/a; Color: Chrome; Constituents: Single lever; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6151FZ-105(2021); Features: Touchless;Battery-operated;Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6151FZ-105(2020); Name: 6151FZ-105(2020) Washbasin faucet, 6 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 65x155x130 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0396552 m2; Volume: 0.00131774 m3
Identity Data - Mark: 7
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6151FZ-105(2021): 6151FZ-105(2020) Washbasin faucet, 6 V, Bluetooth; Family and Type: 6151FZ-105(2021): 6151FZ-105(2020) Washbasin faucet, 6 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6151FZ-105(2021): 6151FZ-105(2020) Washbasin faucet, 6 V, Bluetooth; Type Id: 6151FZ-105(2021): 6151FZ-105(2020) Washbasin faucet, 6 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
